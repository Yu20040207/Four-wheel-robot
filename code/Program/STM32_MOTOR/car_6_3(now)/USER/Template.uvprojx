# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\ADC;..\HAREWARE\KEY;..\HAREWARE\TIM;..\HAREWARE\OLED;..\HAREWARE\LED;..\HAREWARE\USART_X;..\HAREWARE\I2C;..\HAREWARE\ICM20948;..\HAREWARE\Encoder;..\HAREWARE\MOTOR;..\BALANCE\CONCTRL;..\BALANCE\SHOW;..\HAREWARE\CONTROL;..\HAREWARE\AVOIDANCE;..\HAREWARE\VOICE_CONTROL;..\HAREWARE\USART2_HANDLER;..\HAREWARE\LineFollow
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HAREWARE
    ../HAREWARE/KEY/: KEY.c
    ../HAREWARE/OLED/: oled.c
    ../HAREWARE/LED/: LED.c
    ../HAREWARE/USART_X/: usart_x.c
    ../HAREWARE/I2C/: I2C.c
    ../HAREWARE/ICM20948/: ICM20948.c
    ../HAREWARE/Encoder/: Encoder.c
    ../HAREWARE/TIM/: TIM.c
    ../HAREWARE/MOTOR/: motor.c
    ../HAREWARE/ADC/: adc.c
    ../HAREWARE/CONTROL/: control.c
    ../HAREWARE/AVOIDANCE/: avoidance.c avoidance.h
    ../HAREWARE/VOICE_CONTROL/: voice_control.c voice_control.h
    ../HAREWARE/USART2_HANDLER/: usart2_handler.c usart2_handler.h
    ../HAREWARE/LineFollow/: LineFollow.c LineFollow.h
  group BALANCE
    ../BALANCE/CONCTRL/: conctrl.c
    ../BALANCE/SHOW/: show.c
