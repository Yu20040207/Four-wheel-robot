# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\I2C_CTL;..\STM32_LIB\inc;..\SYSTEM\core_cm3;..\SYSTEM\startup;..\SYSTEM\sys;..\APP;..\HARDWARE\LED;..\SYSTEM\delay;..\HARDWARE\BSP;..\HARDWARE\USART;..\HARDWARE\SERVO;..\HARDWARE\TIMER;..\HARDWARE\ENGINE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\SYSTEM\timer;..\HARDWARE\HCSR04;..\HARDWARE\USART2;..\HARDWARE\RANGING;..\HARDWARE\USART3;..\HARDWARE\SERIAL_DISPOSE;..\HARDWARE\TRACKING
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: Key.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/I2C_CTL/: i2c_ctl.c
    ../HARDWARE/SERVO/: bus_servo.c
    ../HARDWARE/TIMER/: timer_delay.c
    ../HARDWARE/ENGINE/: engine.c
    ../HARDWARE/RANGING/: ranging.c
    ../HARDWARE/SERIAL_DISPOSE/: serial_dispose.c
  group STM32_LIB
    ../STM32_LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/core_cm3/: core_cm3.c
    ../SYSTEM/startup/: startup_stm32f10x_hd.s
    ../SYSTEM/timer/: Timer.c
software components: CMSIS:CORE 5.0.2
